## drivers/staging/iio/imu/Kconfig
```kconfig
#
# IIO imu drivers configuration
#
menu "Inertial measurement units"

source "drivers/staging/iio/imu/mpu/Kconfig"
endmenu
```
